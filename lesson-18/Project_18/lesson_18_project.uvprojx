# Keil uVision project lesson_18_project.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson_18_project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Werror=missing-prototypes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
  group System
    ./: bsp.h bsp.c user_startup_TM4C123.s user_system_TM4C123.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
